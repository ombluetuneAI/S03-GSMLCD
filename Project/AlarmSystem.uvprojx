# Keil uVision project AlarmSystem.uvprojx, settings and files
target AlarmSystem (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: AlarmSystem +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, USE_WIRELESSKEYBOARD
  c include: ..\SourceFile\APP\Inc;..\SourceFile\CMSIS\CM3\CoreSupport;..\SourceFile\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\SourceFile\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;..\SourceFile\Device\Inc;..\SourceFile\Common\Inc;..\SourceFile\Common\delay;..\SourceFile\Common\sys;..\SourceFile\BSP\Inc;..\SourceFile\CMSIS\STM32F10x_StdPeriph_Driver\inc;..\SourceFile\UI\STemWinLibrary522\Config\Inc;..\SourceFile\UI\STemWinLibrary522\inc;..\SourceFile\test;..\SourceFile\mOS\System;..\SourceFile\mOS\OS;..\SourceFile\mOS\Device;..\SourceFile\mOS\Device\Inc;..\SourceFile\UI\SystemGUI\Inc;..\SourceFile\UI\STemWinLibrary522\GUIDemo;..\SourceFile\UI\STemWinLibrary522\Demo;..\SourceFile\UI\STemWinLibrary522\emWin_V5.18\GUI\PNG;..\SourceFile\SystemCore\T9Input\inc;..\SourceFile\SystemCore\SystemSet\Inc;..\SourceFile\FATFS\src;..\MSOS+GUI\AlarmSystemCodeProject\SourceFile\mOS\Device\Inc;..\SourceFile\PICTURE;..\SourceFile\RTT
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group StartupMDK
    ../SourceFile/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group CMSIS
    ../SourceFile/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../SourceFile/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group STM32F10x_StdPeriph_Driver
    ../SourceFile/CMSIS/STM32F10x_StdPeriph_Driver/src/: stm32f10x_tim.c stm32f10x_usart.c misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_pwr.c
  group APP
    ../SourceFile/APP/Src/: App.c TaskMenu.c TaskLogic.c SetupMenu.c PhoneMenu.c ZoneMenu.c RecordMenu.c SecurintyMenu.c MenuList.c WirelessProcess.c EventProcess.c ScreensaverTime.c LogProcess.c CallMenu.c AboutMemu.c
  group BSP
    ../SourceFile/BSP/Src/: BSP.c
  group Common
    ../SourceFile/Common/Src/: stm32f10x_it.c sys.c
  group STemWin
    ../SourceFile/UI/STemWinLibrary522/OS/: GUI_X.c
    ../SourceFile/UI/STemWinLibrary522/Config/Src/: GUIConf.c GUIDRV_Template.c LCDConf_FlexColor_Template.c
    ../SourceFile/UI/STemWinLibrary522/Lib/: STemWin522_CM3_Keil.lib
  group SystemSet
    ../SourceFile/SystemCore/SystemSet/Scr/: Systemset.c
  group Security
    ../SourceFile/SystemCore/Security/Src/: PasswordManagement.c
  group System.OS
    ../SourceFile/mOS/OS/: os.c
  group System
    ../SourceFile/mOS/System/: system.c
  group System.Device
    ../SourceFile/mOS/Device/Src/: device_key.c device_systick.c device_IIC.c device_Wireless.c device_Lcd.c device_LED.c device_Voice.c device_timer.c device_storage.c device_adc.c device_usart.c device_GSM.c device_RTC.c device_Flash.c device_SpiFlash.c device_Call.c device_Frequency.c spi.c flash.c
  group System.GUI
    ../SourceFile/UI/SystemGUI/Src/: SystemGUI.c
    ../SourceFile/UI/STemWinLibrary522/Config/Src/: emWinGUI.c
    ../SourceFile/test/: boot.c
  group FatFs
    ../SourceFile/FATFS/src/: diskio.c ff.c
  group PIC
    ../SourceFile/PICTURE/: bmp.c desktop.c about.c contacts.c log.c phone.c recorder.c security.c sensors.c setting.c logo.c logIco.c setIco.c memberIco.c recordeIco.c securityIco.c sensorsIco.c alarm.c
    ../SourceFile/test/: wait.c
  group RTT
    ../SourceFile/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
